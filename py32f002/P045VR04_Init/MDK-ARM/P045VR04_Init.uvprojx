# Keil uVision project P045VR04_Init.uvprojx, settings and files
target PY32F002Ax5_Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: P045VR04_Init +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\Inc;..\..\..\PY32F0xx_Firmware_V1.5.0\Drivers\CMSIS\Include;..\..\..\PY32F0xx_Firmware_V1.5.0\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\PY32F0xx_Firmware_V1.5.0\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f002xx.s
  group Application/User
    ../Src/: main.c panel_st7701.c py32f0xx_hal_msp.c py32f0xx_it.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../PY32F0xx_Firmware_V1.5.0/Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_cortex.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_gpio.c py32f0xx_hal_uart.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
